# IAR project K64master1212.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VLL12; USING_NCN8025_INTERFACE=1; FRDM_K64F; FREEDOM; CD_USING_GPIO; SD_DISK_ENABLE=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../platform/osa/inc; ../platform/utilities/inc; ../platform/CMSIS/Include; ../platform/devices; ../platform/devices/MK64F12/include; ../platform/devices/MK64F12/startup; ../platform/hal/inc; ../platform/drivers/inc; ../platform/system/inc; ../../..; ../board; ../platform/drivers/src/adc16; ../platform/drivers/src/cmp; ../platform/drivers/src/cmt; ../platform/drivers/src/crc; ../platform/drivers/src/dac; ../platform/drivers/src/dspi; ../platform/drivers/src/edma; ../platform/drivers/src/enet; ../platform/drivers/src/ewm; ../platform/drivers/src/flexbus; ../platform/drivers/src/flexcan; ../platform/drivers/src/ftm; ../platform/drivers/src/gpio; ../platform/drivers/src/i2c; ../platform/drivers/src/lptmr; ../platform/drivers/src/mpu; ../platform/drivers/src/pdb; ../platform/drivers/src/pit; ../platform/drivers/src/rnga; ../platform/drivers/src/rtc; ../platform/drivers/src/sai; ../platform/drivers/src/sdhc; ../platform/drivers/src/uart; ../platform/drivers/src/vref; ../platform/drivers/src/wdog; ../platform/drivers/src/smartcard; ../platform/drivers/src/smartcard/interface; ..\fatfs; ..\fatfs\fsl_sd_disk; ..\platform\composite\inc; ..\platform\composite\src\sdcard; ..\fatfs\fsl_sd_disk\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: K64master1212.bin
  ILINK.IlinkOutputFile: K64master1212.out
  ILINK.IlinkIcfFile: ../platform/devices/MK64F12/linker/iar/MK64FN1M0xxx12_flash.icf
  ILINK.IlinkAdditionalLibs: ../lib/ksdk_platform_lib/iar/K64F12/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12; USING_NCN8025_INTERFACE=1; FRDM_K64F; FREEDOM
  ICCARM.CCIncludePath2: ../platform/osa/inc; ../platform/utilities/inc; ../platform/CMSIS/Include; ../platform/devices; ../platform/devices/MK64F12/include; ../platform/devices/MK64F12/startup; ../platform/hal/inc; ../platform/drivers/inc; ../platform/system/inc; ../../..; ../board; ../platform/drivers/src/adc16; ../platform/drivers/src/cmp; ../platform/drivers/src/cmt; ../platform/drivers/src/crc; ../platform/drivers/src/dac; ../platform/drivers/src/dspi; ../platform/drivers/src/edma; ../platform/drivers/src/enet; ../platform/drivers/src/ewm; ../platform/drivers/src/flexbus; ../platform/drivers/src/flexcan; ../platform/drivers/src/ftm; ../platform/drivers/src/gpio; ../platform/drivers/src/i2c; ../platform/drivers/src/lptmr; ../platform/drivers/src/mpu; ../platform/drivers/src/pdb; ../platform/drivers/src/pit; ../platform/drivers/src/rnga; ../platform/drivers/src/rtc; ../platform/drivers/src/sai; ../platform/drivers/src/sdhc; ../platform/drivers/src/uart; ../platform/drivers/src/vref; ../platform/drivers/src/wdog; ../platform/drivers/src/smartcard; ../platform/drivers/src/smartcard/interface
  ICCARM.CCOptLevel: 3
  group board
    ../board/: board.c board.h gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h
    ../: hardware_init.c
  group composite/inc
    ../platform/composite/inc/: fsl_sdhc_card.h fsl_sdmmc_card.h
  group composite/src
    ../platform/composite/src/sdcard/: fsl_sdhc_card.c
  group fatfs
    ../fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h
  group fatfs/fsl_sd_disk
    ../fatfs/fsl_sd_disk/src/: fsl_sd_disk.c
    ../fatfs/fsl_sd_disk/: fsl_sd_disk.h
  group sources
    ../: main.c main.h
  group startup
    ../platform/devices/: startup.c startup.h
    ../platform/devices/MK64F12/startup/iar/: startup_MK64F12.s
    ../platform/devices/MK64F12/startup/: system_MK64F12.c system_MK64F12.h
  group utilities
    ../platform/utilities/src/: fsl_debug_console.c print_scan.c
    ../platform/utilities/inc/: fsl_debug_console.h print_scan.h
